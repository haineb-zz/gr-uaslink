<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>asl_sitl_stub</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_2</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>uaslink_mavlink_control</key>
<param><key>id</key><value>uaslink_mavlink_control_0</value></param>
<param><key>baud_rate</key><value>57600</value></param>
<param><key>connection_string</key><value>'127.0.0.1:14560'</value></param>
</block>
<block>
<key>uaslink_pymavlink_source_sink_pp</key>
<param><key>id</key><value>uaslink_pymavlink_source_sink_pp_1</value></param>
<param><key>baud_rate</key><value>57600</value></param>
<param><key>connection_string</key><value>'tcp:127.0.0.1:5763'</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:6128</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_1</value></param>
<param><key>address</key><value>tcp://127.0.0.1:6130</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:14000'</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_1</value></param>
<param><key>address</key><value>tcp://127.0.0.1:6129</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_2</value></param>
<param><key>address</key><value>tcp://127.0.0.1:6131</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>uaslink_mavlink_control_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>MAVLink_OUT</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>uaslink_mavlink_control_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>MAVLink_OUT</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>uaslink_pymavlink_source_sink_pp_1</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>MAVLink_OUT</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>uaslink_pymavlink_source_sink_pp_1</source_block_id><sink_block_id>zeromq_pub_msg_sink_1</sink_block_id><source_key>MAVLink_OUT</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>uaslink_mavlink_control_0</sink_block_id><source_key>out</source_key><sink_key>Command</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_1</source_block_id><sink_block_id>blocks_message_debug_2</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_1</source_block_id><sink_block_id>uaslink_pymavlink_source_sink_pp_1</sink_block_id><source_key>out</source_key><sink_key>MAVLink_IN</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_2</source_block_id><sink_block_id>uaslink_mavlink_control_0</sink_block_id><source_key>out</source_key><sink_key>MAVLink_IN</sink_key></connection>
</flow_graph>
